

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO ecc_mux_isolated 
  PIN data_in_left[0] 
    ANTENNAPARTIALMETALAREA 7.803 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 35.2485 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4225 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 21.0691 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 95.5977 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.941111 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 11.115 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 50.5575 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0254 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 26.5569 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 120.559 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.12578 LAYER Via4 ;
  END data_in_left[0]
  PIN data_in_left[1] 
    ANTENNAPARTIALMETALAREA 5.848 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.496 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4597 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 18.823 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 85.1124 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.556616 LAYER Via3 ;
  END data_in_left[1]
  PIN data_in_left[2] 
    ANTENNAPARTIALMETALAREA 11.7268 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 52.938 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.4508 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 36.5917 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 165.035 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.79625 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.555 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.1775 LAYER Metal4 ;
    ANTENNAGATEAREA 2.1359 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 39.1925 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 176.823 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.79625 LAYER Via4 ;
  END data_in_left[2]
  PIN data_in_left[3] 
    ANTENNAPARTIALMETALAREA 8.504 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 38.403 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2418 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 38.8619 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 175.811 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER Via3 ;
    ANTENNAMAXCUTCAR 1.49297 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.798 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.131 LAYER Metal4 ;
    ANTENNAGATEAREA 1.9344 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 42.3761 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 191.904 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.49297 LAYER Via4 ;
  END data_in_left[3]
  PIN data_in_left[4] 
    ANTENNAPARTIALMETALAREA 11.8626 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 53.3565 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.209 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.7602 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 62.8124 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.716625 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.619 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.1455 LAYER Metal4 ;
    ANTENNAGATEAREA 1.9344 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.1819 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 78.3964 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_left[4]
  PIN data_in_left[5] 
    ANTENNAPARTIALMETALAREA 7.487 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.849 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7254 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 21.3998 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 96.89 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.995313 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.907 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.239 LAYER Metal4 ;
    ANTENNAGATEAREA 0.9672 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.3375 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 101.273 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 1.06996 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.856 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 31.032 LAYER Metal5 ;
    ANTENNAGATEAREA 1.6432 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 28.0019 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 127.806 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.29206 LAYER TopVia1 ;
  END data_in_left[5]
  PIN data_in_left[6] 
    ANTENNAPARTIALMETALAREA 6.994 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.4505 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.999 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.3555 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.8733 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.0149 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 77.5019 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.32017 LAYER Via4 ;
  END data_in_left[6]
  PIN data_in_left[7] 
    ANTENNAPARTIALMETALAREA 3.965 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4342 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 37.1938 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 170.029 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 1.36066 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.325 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.62 LAYER Metal4 ;
    ANTENNAGATEAREA 0.4342 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 37.9423 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 173.76 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 1.52694 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.831 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.4195 LAYER Metal5 ;
    ANTENNAGATEAREA 1.885 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 42.0967 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 192.55 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.52694 LAYER TopVia1 ;
  END data_in_left[7]
  PIN data_in_left[8] 
    ANTENNAPARTIALMETALAREA 14.0268 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 63.108 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 24.7598 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 110.564 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.857324 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.843 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9735 LAYER Metal4 ;
    ANTENNAGATEAREA 1.1596 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 27.2115 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 121.752 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.857324 LAYER Via4 ;
  END data_in_left[8]
  PIN data_in_left[9] 
    ANTENNAPARTIALMETALAREA 13.98 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 63.4275 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0044 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 19.9105 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 90.7324 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.967665 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.752 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.564 LAYER Metal4 ;
    ANTENNAGATEAREA 1.2462 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.5139 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 93.5922 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.967665 LAYER Via4 ;
  END data_in_left[9]
  PIN data_in_left[10] 
    ANTENNAPARTIALMETALAREA 0.174 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7605 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.443 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.151 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 12.064 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 54.468 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1968 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 36.4602 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 164.736 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.902371 LAYER TopVia1 ;
  END data_in_left[10]
  PIN data_in_left[11] 
    ANTENNAPARTIALMETALAREA 14.205 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 64.1025 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.209 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 22.5156 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 101.822 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.597188 LAYER Via3 ;
  END data_in_left[11]
  PIN data_in_left[12] 
    ANTENNAPARTIALMETALAREA 9.908 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 44.5635 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4225 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 26.0256 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 117.961 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.770223 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.432 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.124 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5704 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 28.6589 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 129.804 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.26157 LAYER Via4 ;
  END data_in_left[12]
  PIN data_in_left[13] 
    ANTENNAPARTIALMETALAREA 18.912 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 85.464 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.209 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 24.6017 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 111.618 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via3 ;
  END data_in_left[13]
  PIN data_in_left[14] 
    ANTENNAPARTIALMETALAREA 0.174 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7605 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.571 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.727 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.696 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 39.312 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1323 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 17.2112 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 77.8265 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.659846 LAYER TopVia1 ;
  END data_in_left[14]
  PIN data_in_left[15] 
    ANTENNAPARTIALMETALAREA 9.576 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 43.0695 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.792 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.244 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9178 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 31.9744 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 144.3 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.829186 LAYER Via4 ;
  END data_in_left[15]
  PIN data_out_right_up[0] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 13.864 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 62.388 LAYER Metal4 ;
  END data_out_right_up[0]
  PIN data_out_right_up[1] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[1]
  PIN data_out_right_up[2] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.315 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9175 LAYER Metal4 ;
  END data_out_right_up[2]
  PIN data_out_right_up[3] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[3]
  PIN data_out_right_up[4] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.055 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
  END data_out_right_up[4]
  PIN data_out_right_up[5] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 14.023 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 63.1035 LAYER Metal4 ;
  END data_out_right_up[5]
  PIN data_out_right_up[6] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.307 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3815 LAYER Metal4 ;
  END data_out_right_up[6]
  PIN data_out_right_up[7] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[7]
  PIN data_out_right_up[8] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.055 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
  END data_out_right_up[8]
  PIN data_out_right_up[9] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 15.88 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 71.46 LAYER Metal4 ;
  END data_out_right_up[9]
  PIN data_out_right_up[10] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 15.04 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 67.68 LAYER Metal4 ;
  END data_out_right_up[10]
  PIN data_out_right_up[11] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 15.544 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 69.948 LAYER Metal4 ;
  END data_out_right_up[11]
  PIN data_out_right_up[12] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.055 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
  END data_out_right_up[12]
  PIN data_out_right_up[13] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.307 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3815 LAYER Metal4 ;
  END data_out_right_up[13]
  PIN data_out_right_up[14] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 16.111 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 72.4995 LAYER Metal4 ;
  END data_out_right_up[14]
  PIN data_out_right_up[15] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 13.075 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 58.8375 LAYER Metal4 ;
  END data_out_right_up[15]
  PIN data_out_right_down[0] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.756 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.902 LAYER Metal4 ;
  END data_out_right_down[0]
  PIN data_out_right_down[1] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.964 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.838 LAYER Metal4 ;
  END data_out_right_down[1]
  PIN data_out_right_down[2] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.448 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.016 LAYER Metal4 ;
  END data_out_right_down[2]
  PIN data_out_right_down[3] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.828 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.226 LAYER Metal4 ;
  END data_out_right_down[3]
  PIN data_out_right_down[4] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.38 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.21 LAYER Metal4 ;
  END data_out_right_down[4]
  PIN data_out_right_down[5] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.399 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2955 LAYER Metal4 ;
  END data_out_right_down[5]
  PIN data_out_right_down[6] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.532 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.394 LAYER Metal4 ;
  END data_out_right_down[6]
  PIN data_out_right_down[7] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.391 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7595 LAYER Metal4 ;
  END data_out_right_down[7]
  PIN data_out_right_down[8] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.744 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.848 LAYER Metal4 ;
  END data_out_right_down[8]
  PIN data_out_right_down[9] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.903 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5635 LAYER Metal4 ;
  END data_out_right_down[9]
  PIN data_out_right_down[10] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.604 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.218 LAYER Metal4 ;
  END data_out_right_down[10]
  PIN data_out_right_down[11] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.192 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.864 LAYER Metal4 ;
  END data_out_right_down[11]
  PIN data_out_right_down[12] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.746 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.537 LAYER Metal4 ;
  END data_out_right_down[12]
  PIN data_out_right_down[13] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.952 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.464 LAYER Metal4 ;
  END data_out_right_down[13]
  PIN data_out_right_down[14] 
    ANTENNADIFFAREA 1.058 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 7.564 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.218 LAYER Metal4 ;
  END data_out_right_down[14]
  PIN data_out_right_down[15] 
    ANTENNAPARTIALMETALAREA 4.69 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.0825 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNADIFFAREA 1.058 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 8.702 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 39.339 LAYER Metal5 ;
  END data_out_right_down[15]
  PIN data_in_right_up[0] 
    ANTENNAPARTIALMETALAREA 5.608 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.236 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1968 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.8664 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 67.3966 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.508218 LAYER Via4 ;
  END data_in_right_up[0]
  PIN data_in_right_up[1] 
    ANTENNAPARTIALMETALAREA 5.221 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.6745 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9178 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 27.9768 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 126.519 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via4 ;
  END data_in_right_up[1]
  PIN data_in_right_up[2] 
    ANTENNAPARTIALMETALAREA 5.755 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.8975 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9672 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.5337 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 87.9461 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.97043 LAYER Via4 ;
  END data_in_right_up[2]
  PIN data_in_right_up[3] 
    ANTENNAPARTIALMETALAREA 7.458 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.741 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9178 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.9718 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.4963 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via4 ;
  END data_in_right_up[3]
  PIN data_in_right_up[4] 
    ANTENNAPARTIALMETALAREA 2.743 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3435 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 28.8102 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 130.585 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.00259 LAYER Via4 ;
  END data_in_right_up[4]
  PIN data_in_right_up[5] 
    ANTENNAPARTIALMETALAREA 0.06 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.269 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 19.3905 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 40.479 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 181.871 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.15188 LAYER TopVia1 ;
  END data_in_right_up[5]
  PIN data_in_right_up[6] 
    ANTENNAPARTIALMETALAREA 5.779 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.0055 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 25.8462 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 116.336 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.857324 LAYER Via4 ;
  END data_in_right_up[6]
  PIN data_in_right_up[7] 
    ANTENNAPARTIALMETALAREA 9.715 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 43.7175 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 26.7091 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 118.312 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.857324 LAYER Via4 ;
  END data_in_right_up[7]
  PIN data_in_right_up[8] 
    ANTENNAPARTIALMETALAREA 9.989 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.1305 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3494 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.1337 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 68.9318 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.770223 LAYER Via4 ;
  END data_in_right_up[8]
  PIN data_in_right_up[9] 
    ANTENNAPARTIALMETALAREA 7.143 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 32.3235 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1687 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.5637 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 71.1905 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via4 ;
  END data_in_right_up[9]
  PIN data_in_right_up[10] 
    ANTENNAPARTIALMETALAREA 2.752 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.384 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6266 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.4975 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 60.1105 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.865745 LAYER Via4 ;
  END data_in_right_up[10]
  PIN data_in_right_up[11] 
    ANTENNAPARTIALMETALAREA 7.038 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.851 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1687 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.568 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 80.3282 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.04508 LAYER Via4 ;
  END data_in_right_up[11]
  PIN data_in_right_up[12] 
    ANTENNAPARTIALMETALAREA 8.886 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.167 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 29.152 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 132.199 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.50104 LAYER Via4 ;
  END data_in_right_up[12]
  PIN data_in_right_up[13] 
    ANTENNAPARTIALMETALAREA 11.68 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 52.56 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.1722 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 83.8258 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.815024 LAYER Via4 ;
  END data_in_right_up[13]
  PIN data_in_right_up[14] 
    ANTENNAPARTIALMETALAREA 7.888 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.496 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 21.155 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 95.2158 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.916803 LAYER Via4 ;
  END data_in_right_up[14]
  PIN data_in_right_up[15] 
    ANTENNAPARTIALMETALAREA 12.643 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 56.8935 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 23.1637 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 104.517 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.857324 LAYER Via4 ;
  END data_in_right_up[15]
  PIN data_in_right_down[0] 
    ANTENNAPARTIALMETALAREA 15.916 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 71.7795 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2418 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 69.5194 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 314.607 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 1.19438 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 11.188 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 50.526 LAYER Metal5 ;
    ANTENNAGATEAREA 1.3611 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 77.7393 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 351.729 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.19438 LAYER TopVia1 ;
  END data_in_right_down[0]
  PIN data_in_right_down[1] 
    ANTENNAPARTIALMETALAREA 15.242 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 68.7465 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 27.3003 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 124.088 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.853289 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 3.8 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 17.28 LAYER Metal5 ;
    ANTENNAGATEAREA 0.9178 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 31.4407 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 142.916 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER TopVia1 ;
  END data_in_right_down[1]
  PIN data_in_right_down[2] 
    ANTENNAPARTIALMETALAREA 17.088 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 76.8735 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 15.88 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 71.64 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3611 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 23.6603 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 107.458 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.04508 LAYER TopVia1 ;
  END data_in_right_down[2]
  PIN data_in_right_down[3] 
    ANTENNAPARTIALMETALAREA 12.843 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 57.9735 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9178 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 40.9758 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 185.002 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.810797 LAYER Via4 ;
  END data_in_right_down[3]
  PIN data_in_right_down[4] 
    ANTENNAPARTIALMETALAREA 16.76 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 75.5775 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 38.158 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 172.607 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.662545 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.687 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 39.2715 LAYER Metal5 ;
    ANTENNAGATEAREA 1.9968 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 42.5085 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 192.275 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.662545 LAYER TopVia1 ;
  END data_in_right_down[4]
  PIN data_in_right_down[5] 
    ANTENNAPARTIALMETALAREA 13.116 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 59.202 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 36.0083 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 162.92 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_right_down[5]
  PIN data_in_right_down[6] 
    ANTENNAPARTIALMETALAREA 16.25 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 73.2825 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8684 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 28.6415 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 129.633 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.498848 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.932 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 44.874 LAYER Metal5 ;
    ANTENNAGATEAREA 2.0124 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 33.5769 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 151.932 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.809597 LAYER TopVia1 ;
  END data_in_right_down[6]
  PIN data_in_right_down[7] 
    ANTENNAPARTIALMETALAREA 13.347 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 60.2415 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 29.1021 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 131.004 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.469711 LAYER Via4 ;
  END data_in_right_down[7]
  PIN data_in_right_down[8] 
    ANTENNAPARTIALMETALAREA 15.096 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 67.9095 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.064 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 31.968 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0044 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 15.2966 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 69.2994 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.66133 LAYER TopVia1 ;
  END data_in_right_down[8]
  PIN data_in_right_down[9] 
    ANTENNAPARTIALMETALAREA 13.504 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 60.768 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7254 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 33.6136 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 152.339 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.995313 LAYER Via4 ;
  END data_in_right_down[9]
  PIN data_in_right_down[10] 
    ANTENNAPARTIALMETALAREA 20.551 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 92.4795 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7254 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 47.5019 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 214.216 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.547422 LAYER Via4 ;
  END data_in_right_down[10]
  PIN data_in_right_down[11] 
    ANTENNAPARTIALMETALAREA 16.107 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 72.6615 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7254 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 41.4464 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 187.746 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via4 ;
  END data_in_right_down[11]
  PIN data_in_right_down[12] 
    ANTENNAPARTIALMETALAREA 3.504 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.7455 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.229 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 28.3905 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7254 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 48.3671 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 219.105 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.19438 LAYER TopVia1 ;
  END data_in_right_down[12]
  PIN data_in_right_down[13] 
    ANTENNAPARTIALMETALAREA 12.372 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 55.6515 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 3.116 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 14.202 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9269 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 13.083 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 60.1233 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.12297 LAYER TopVia1 ;
  END data_in_right_down[13]
  PIN data_in_right_down[14] 
    ANTENNAPARTIALMETALAREA 21.328 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 95.976 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7254 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 36.6765 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 165.054 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.696719 LAYER Via4 ;
  END data_in_right_down[14]
  PIN data_in_right_down[15] 
    ANTENNAPARTIALMETALAREA 11.192 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 50.364 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7254 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.6563 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 93.7386 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.34836 LAYER Via4 ;
  END data_in_right_down[15]
  PIN data_out_left[0] 
    ANTENNADIFFAREA 1.058 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.031 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.8195 LAYER Metal3 ;
  END data_out_left[0]
  PIN data_out_left[1] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.3988 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.1245 LAYER Metal3 ;
  END data_out_left[1]
  PIN data_out_left[2] 
    ANTENNADIFFAREA 1.058 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 7.3348 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.0165 LAYER Metal3 ;
  END data_out_left[2]
  PIN data_out_left[3] 
    ANTENNADIFFAREA 1.1028 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 9.055 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 40.7475 LAYER Metal3 ;
  END data_out_left[3]
  PIN data_out_left[4] 
    ANTENNAPARTIALMETALAREA 1.998 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9685 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.051 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.9095 LAYER Metal4 ;
  END data_out_left[4]
  PIN data_out_left[5] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.223 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.6835 LAYER Metal3 ;
  END data_out_left[5]
  PIN data_out_left[6] 
    ANTENNADIFFAREA 1.058 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 6.639 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.0555 LAYER Metal3 ;
  END data_out_left[6]
  PIN data_out_left[7] 
    ANTENNAPARTIALMETALAREA 2.974 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3605 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 1.1028 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.039 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.8555 LAYER Metal4 ;
  END data_out_left[7]
  PIN data_out_left[8] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.309 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.8905 LAYER Metal3 ;
  END data_out_left[8]
  PIN data_out_left[9] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 4.839 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.9555 LAYER Metal3 ;
  END data_out_left[9]
  PIN data_out_left[10] 
    ANTENNADIFFAREA 1.1028 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 8.299 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.3455 LAYER Metal3 ;
  END data_out_left[10]
  PIN data_out_left[11] 
    ANTENNADIFFAREA 1.1028 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 8.475 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 38.3175 LAYER Metal3 ;
  END data_out_left[11]
  PIN data_out_left[12] 
    ANTENNADIFFAREA 1.1028 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 6.196 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.882 LAYER Metal3 ;
  END data_out_left[12]
  PIN data_out_left[13] 
    ANTENNAPARTIALMETALAREA 3.726 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.7445 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.647 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.0915 LAYER Metal4 ;
  END data_out_left[13]
  PIN data_out_left[14] 
    ANTENNADIFFAREA 1.058 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 9.772 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 43.974 LAYER Metal3 ;
  END data_out_left[14]
  PIN data_out_left[15] 
    ANTENNAPARTIALMETALAREA 6.51 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.2725 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 1.1028 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 13.236 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 59.742 LAYER Metal4 ;
  END data_out_left[15]
  PIN sel[2] 
    ANTENNAPARTIALMETALAREA 3.591 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.3395 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0044 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 9.2912 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 41.75 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.589446 LAYER Via3 ;
  END sel[2]
  PIN sel[1] 
    ANTENNAPARTIALMETALAREA 4.252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.314 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4342 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.7436 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 57.8082 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.75052 LAYER Via3 ;
  END sel[1]
  PIN sel[0] 
    ANTENNAPARTIALMETALAREA 2.094 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.4005 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 14.508 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 65.466 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3281 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 29.2478 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 131.935 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.18014 LAYER Via4 ;
  END sel[0]
  PIN flag[0] 
    ANTENNADIFFAREA 0.9814 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 9.194 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 41.5305 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.279 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 34.4468 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 155.973 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.646953 LAYER Via3 ;
    ANTENNADIFFAREA 0.9814 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.831 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.397 LAYER Metal4 ;
    ANTENNAGATEAREA 0.279 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 41.0095 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 186.07 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.905735 LAYER Via4 ;
    ANTENNADIFFAREA 0.9814 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 6.188 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 28.026 LAYER Metal5 ;
    ANTENNAGATEAREA 1.488 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 45.1681 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 204.905 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.905735 LAYER TopVia1 ;
  END flag[0]
  PIN flag[1] 
    ANTENNADIFFAREA 0.662 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 10.881 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 48.942 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4836 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 26.2957 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 118.3 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.597188 LAYER Via3 ;
    ANTENNADIFFAREA 0.662 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.842 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.469 LAYER Metal4 ;
    ANTENNAGATEAREA 1.1479 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 29.6427 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 133.518 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.9078 LAYER Via4 ;
  END flag[1]
  PIN flag[2] 
    ANTENNAPARTIALMETALAREA 4.272 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.2015 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.992 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.644 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1807 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 75.7346 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 343.572 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.998893 LAYER Via4 ;
  END flag[2]
  PIN chip_sel_out[1] 
    ANTENNADIFFAREA 0.7586 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.628 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.326 LAYER Metal3 ;
  END chip_sel_out[1]
  PIN chip_sel_out[0] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.247 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6115 LAYER Metal3 ;
  END chip_sel_out[0]
  PIN chip_sel 
    ANTENNAPARTIALMETALAREA 5.487 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.8715 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9277 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.8446 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 56.8397 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.57586 LAYER Via3 ;
  END chip_sel
END ecc_mux_isolated

END LIBRARY
