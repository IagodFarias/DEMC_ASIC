

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO ecc_tbec_only 
  PIN data_in_left[0] 
    ANTENNAPARTIALMETALAREA 10.297 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 46.854 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 16.5843 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 75.5484 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.960815 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.47 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.295 LAYER Metal4 ;
    ANTENNAGATEAREA 1.3026 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 21.5513 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 98.0381 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.12578 LAYER Via4 ;
  END data_in_left[0]
  PIN data_in_left[1] 
    ANTENNAPARTIALMETALAREA 9.589 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 43.5105 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.2867 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 65.052 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.754521 LAYER Via3 ;
  END data_in_left[1]
  PIN data_in_left[2] 
    ANTENNAPARTIALMETALAREA 10.104 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 45.648 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 17.9152 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 83.4343 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.447891 LAYER Via3 ;
  END data_in_left[2]
  PIN data_in_left[3] 
    ANTENNAPARTIALMETALAREA 8.375 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.8675 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 16.9243 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 76.7121 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via3 ;
  END data_in_left[3]
  PIN data_in_left[4] 
    ANTENNAPARTIALMETALAREA 8.754 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 39.5505 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 15.0129 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 68.3914 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.662221 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.728 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.956 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.3519 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 79.0301 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.662221 LAYER Via4 ;
  END data_in_left[4]
  PIN data_in_left[5] 
    ANTENNAPARTIALMETALAREA 0.174 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7605 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 11.231 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 50.8995 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3026 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 33.4644 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 151.533 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.12578 LAYER Via4 ;
  END data_in_left[5]
  PIN data_in_left[6] 
    ANTENNAPARTIALMETALAREA 9.0778 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 40.8375 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.8976 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 53.9675 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.960815 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.04 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.36 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.4324 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 65.4872 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.960815 LAYER Via4 ;
  END data_in_left[6]
  PIN data_in_left[7] 
    ANTENNAPARTIALMETALAREA 13.59 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 61.29 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 24.1297 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 109.182 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.725813 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 11.752 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 53.244 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 31.5032 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 142.589 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_left[7]
  PIN data_in_left[8] 
    ANTENNAPARTIALMETALAREA 10.045 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 45.5625 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.499 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 50.436 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.447891 LAYER Via3 ;
  END data_in_left[8]
  PIN data_in_left[9] 
    ANTENNAPARTIALMETALAREA 9.885 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 44.6625 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.7654 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 51.9695 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.447891 LAYER Via3 ;
  END data_in_left[9]
  PIN data_in_left[10] 
    ANTENNAPARTIALMETALAREA 8.229 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.368 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.1121 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 64.1148 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.662221 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.159 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.373 LAYER Metal4 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.1561 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 68.9545 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.727254 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.715 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 34.8975 LAYER Metal5 ;
    ANTENNAGATEAREA 1.3026 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 56.2489 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 254.943 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.50104 LAYER TopVia1 ;
  END data_in_left[10]
  PIN data_in_left[11] 
    ANTENNAPARTIALMETALAREA 10.44 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 46.9575 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.027 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 54.8026 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.662221 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.327 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.6515 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.2516 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 78.4264 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_left[11]
  PIN data_in_left[12] 
    ANTENNAPARTIALMETALAREA 9.1928 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 41.355 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1596 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 20.7328 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 94.9311 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.659451 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.75 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.555 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.4582 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 102.809 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.659451 LAYER Via4 ;
  END data_in_left[12]
  PIN data_in_left[13] 
    ANTENNAPARTIALMETALAREA 2.962 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3065 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 15.4189 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 69.8186 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.703992 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.418 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0385 LAYER Metal4 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.0372 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.8341 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.810797 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 11.447 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 51.6915 LAYER Metal5 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 26.0943 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 116.237 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.810797 LAYER TopVia1 ;
  END data_in_left[13]
  PIN data_in_left[14] 
    ANTENNAPARTIALMETALAREA 13.37 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 60.3225 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.8299 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 67.2344 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.662221 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.255 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.3275 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.0093 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.6548 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_left[14]
  PIN data_in_left[15] 
    ANTENNAPARTIALMETALAREA 10.711 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 48.537 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.5887 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 57.8134 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.662221 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.211 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.1295 LAYER Metal4 ;
    ANTENNAGATEAREA 1.3026 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 33.3926 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 151.271 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.12578 LAYER Via4 ;
  END data_in_left[15]
  PIN data_out_right_up[0] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.176 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.792 LAYER Metal4 ;
  END data_out_right_up[0]
  PIN data_out_right_up[1] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.316 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.422 LAYER Metal4 ;
  END data_out_right_up[1]
  PIN data_out_right_up[2] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.055 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
  END data_out_right_up[2]
  PIN data_out_right_up[3] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.231 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5395 LAYER Metal4 ;
  END data_out_right_up[3]
  PIN data_out_right_up[4] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[4]
  PIN data_out_right_up[5] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.069 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3105 LAYER Metal4 ;
  END data_out_right_up[5]
  PIN data_out_right_up[6] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[6]
  PIN data_out_right_up[7] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.164 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.738 LAYER Metal4 ;
  END data_out_right_up[7]
  PIN data_out_right_up[8] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.903 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5635 LAYER Metal4 ;
  END data_out_right_up[8]
  PIN data_out_right_up[9] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.987 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9415 LAYER Metal4 ;
  END data_out_right_up[9]
  PIN data_out_right_up[10] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.923 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.1535 LAYER Metal4 ;
  END data_out_right_up[10]
  PIN data_out_right_up[11] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.391 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7595 LAYER Metal4 ;
  END data_out_right_up[11]
  PIN data_out_right_up[12] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.736 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.312 LAYER Metal4 ;
  END data_out_right_up[12]
  PIN data_out_right_up[13] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.475 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1375 LAYER Metal4 ;
  END data_out_right_up[13]
  PIN data_out_right_up[14] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.055 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
  END data_out_right_up[14]
  PIN data_out_right_up[15] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 7.219 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 32.4855 LAYER Metal4 ;
  END data_out_right_up[15]
  PIN data_out_right_down[0] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.587 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6415 LAYER Metal4 ;
  END data_out_right_down[0]
  PIN data_out_right_down[1] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.659 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9655 LAYER Metal4 ;
  END data_out_right_down[1]
  PIN data_out_right_down[2] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.652 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.934 LAYER Metal4 ;
  END data_out_right_down[2]
  PIN data_out_right_down[3] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.652 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.934 LAYER Metal4 ;
  END data_out_right_down[3]
  PIN data_out_right_down[4] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.92 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.14 LAYER Metal4 ;
  END data_out_right_down[4]
  PIN data_out_right_down[5] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.136 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.612 LAYER Metal4 ;
  END data_out_right_down[5]
  PIN data_out_right_down[6] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.391 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7595 LAYER Metal4 ;
  END data_out_right_down[6]
  PIN data_out_right_down[7] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.592 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.664 LAYER Metal4 ;
  END data_out_right_down[7]
  PIN data_out_right_down[8] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.344 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.048 LAYER Metal4 ;
  END data_out_right_down[8]
  PIN data_out_right_down[9] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.016 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.572 LAYER Metal4 ;
  END data_out_right_down[9]
  PIN data_out_right_down[10] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.112 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.004 LAYER Metal4 ;
  END data_out_right_down[10]
  PIN data_out_right_down[11] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.704 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.668 LAYER Metal4 ;
  END data_out_right_down[11]
  PIN data_out_right_down[12] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.604 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.218 LAYER Metal4 ;
  END data_out_right_down[12]
  PIN data_out_right_down[13] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.727 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2715 LAYER Metal4 ;
  END data_out_right_down[13]
  PIN data_out_right_down[14] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 7.219 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 32.4855 LAYER Metal4 ;
  END data_out_right_down[14]
  PIN data_out_right_down[15] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 7.518 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.011 LAYER Metal4 ;
  END data_out_right_down[15]
  PIN data_in_right_up[0] 
    ANTENNAPARTIALMETALAREA 6.96 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.2975 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.739 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 35.0055 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 11.0307 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 50.6233 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.726197 LAYER TopVia1 ;
  END data_in_right_up[0]
  PIN data_in_right_up[1] 
    ANTENNAPARTIALMETALAREA 5.635 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.3575 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7667 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.6399 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 71.0614 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.718165 LAYER Via4 ;
  END data_in_right_up[1]
  PIN data_in_right_up[2] 
    ANTENNAPARTIALMETALAREA 2.679 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2355 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7667 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.5039 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 92.1042 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.695201 LAYER Via4 ;
  END data_in_right_up[2]
  PIN data_in_right_up[3] 
    ANTENNAPARTIALMETALAREA 8.403 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.8135 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3325 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.9446 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 74.7944 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.01595 LAYER Via4 ;
  END data_in_right_up[3]
  PIN data_in_right_up[4] 
    ANTENNAPARTIALMETALAREA 6.523 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.3535 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3117 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.4531 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 74.7788 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.543651 LAYER Via4 ;
  END data_in_right_up[4]
  PIN data_in_right_up[5] 
    ANTENNAPARTIALMETALAREA 6.456 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.0295 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 5.339 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 24.2055 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0699 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 9.32947 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 42.9176 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.577709 LAYER TopVia1 ;
  END data_in_right_up[5]
  PIN data_in_right_up[6] 
    ANTENNAPARTIALMETALAREA 7.625 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.3125 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3117 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.9697 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 77.2689 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.75052 LAYER Via4 ;
  END data_in_right_up[6]
  PIN data_in_right_up[7] 
    ANTENNAPARTIALMETALAREA 3.016 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.572 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3208 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 26.0837 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 116.012 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.950445 LAYER Via4 ;
  END data_in_right_up[7]
  PIN data_in_right_up[8] 
    ANTENNAPARTIALMETALAREA 12.596 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 57.042 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.755 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.1277 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 81.1738 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.04508 LAYER Via4 ;
  END data_in_right_up[8]
  PIN data_in_right_up[9] 
    ANTENNAPARTIALMETALAREA 6.712 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.204 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3026 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.31065 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 42.4137 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.503318 LAYER Via4 ;
  END data_in_right_up[9]
  PIN data_in_right_up[10] 
    ANTENNAPARTIALMETALAREA 2.584 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.628 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0608 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.45227 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 42.7311 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.818582 LAYER Via4 ;
  END data_in_right_up[10]
  PIN data_in_right_up[11] 
    ANTENNAPARTIALMETALAREA 4.463 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.061 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.3799 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 62.4247 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 1.10655 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 2.264 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 10.368 LAYER Metal5 ;
    ANTENNAGATEAREA 1.7459 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 15.6767 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 68.3632 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.10655 LAYER TopVia1 ;
  END data_in_right_up[11]
  PIN data_in_right_up[12] 
    ANTENNAPARTIALMETALAREA 10.499 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 47.4255 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7576 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.2436 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 71.9386 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.900344 LAYER Via4 ;
  END data_in_right_up[12]
  PIN data_in_right_up[13] 
    ANTENNAPARTIALMETALAREA 3.424 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.408 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7667 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.1131 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 77.0626 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.05681 LAYER Via4 ;
  END data_in_right_up[13]
  PIN data_in_right_up[14] 
    ANTENNAPARTIALMETALAREA 4.288 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.296 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7667 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 7.98331 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 36.3905 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.718165 LAYER Via4 ;
  END data_in_right_up[14]
  PIN data_in_right_up[15] 
    ANTENNAPARTIALMETALAREA 1.147 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1615 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5535 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 5.41185 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 24.9466 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.391545 LAYER Via4 ;
  END data_in_right_up[15]
  PIN data_in_right_down[0] 
    ANTENNAPARTIALMETALAREA 4.003 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.0135 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.7741 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 89.6185 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.512395 LAYER Via4 ;
  END data_in_right_down[0]
  PIN data_in_right_down[1] 
    ANTENNAPARTIALMETALAREA 6.131 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.747 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3983 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.1626 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 64.4522 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.813565 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.087 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 36.5715 LAYER Metal5 ;
    ANTENNAGATEAREA 1.6401 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 19.0934 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 86.7506 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.04508 LAYER TopVia1 ;
  END data_in_right_down[1]
  PIN data_in_right_down[2] 
    ANTENNAPARTIALMETALAREA 0.223 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0035 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.8715 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.1108 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.494096 LAYER Via4 ;
  END data_in_right_down[2]
  PIN data_in_right_down[3] 
    ANTENNAPARTIALMETALAREA 5.632 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.344 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1284 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.7058 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 102.614 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.552593 LAYER Via4 ;
  END data_in_right_down[3]
  PIN data_in_right_down[4] 
    ANTENNAPARTIALMETALAREA 9.243 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 41.7735 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 25.4508 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 115.906 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.748273 LAYER Via4 ;
  END data_in_right_down[4]
  PIN data_in_right_down[5] 
    ANTENNAPARTIALMETALAREA 11.4731 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 51.786 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4342 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 28.787 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 130.808 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.58199 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.532 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 34.074 LAYER Metal5 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 35.5162 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 161.251 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.04508 LAYER TopVia1 ;
  END data_in_right_down[5]
  PIN data_in_right_down[6] 
    ANTENNAPARTIALMETALAREA 8.034 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.333 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 28.3718 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 128.924 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.6615 LAYER Via4 ;
  END data_in_right_down[6]
  PIN data_in_right_down[7] 
    ANTENNAPARTIALMETALAREA 8.956 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.482 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.8056 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.3669 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.748273 LAYER Via4 ;
  END data_in_right_down[7]
  PIN data_in_right_down[8] 
    ANTENNAPARTIALMETALAREA 10.063 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.2835 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.658 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 102.015 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.512395 LAYER Via4 ;
  END data_in_right_down[8]
  PIN data_in_right_down[9] 
    ANTENNAPARTIALMETALAREA 10.814 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 48.843 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.4978 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 56.3787 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.415707 LAYER Via4 ;
  END data_in_right_down[9]
  PIN data_in_right_down[10] 
    ANTENNAPARTIALMETALAREA 15.719 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 71.0955 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 23.2976 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 105.884 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_right_down[10]
  PIN data_in_right_down[11] 
    ANTENNAPARTIALMETALAREA 11.908 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 53.586 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 21.7904 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 98.5514 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.512924 LAYER Via4 ;
  END data_in_right_down[11]
  PIN data_in_right_down[12] 
    ANTENNAPARTIALMETALAREA 16.635 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 75.0375 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 25.7072 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 116.41 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_right_down[12]
  PIN data_in_right_down[13] 
    ANTENNAPARTIALMETALAREA 13.818 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 62.361 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.0358 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 85.9464 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.512924 LAYER Via4 ;
  END data_in_right_down[13]
  PIN data_in_right_down[14] 
    ANTENNAPARTIALMETALAREA 14.775 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 66.6675 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.0217 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.5359 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.512924 LAYER Via4 ;
  END data_in_right_down[14]
  PIN data_in_right_down[15] 
    ANTENNAPARTIALMETALAREA 14.224 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 64.008 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.4243 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 83.4289 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.553113 LAYER Via4 ;
  END data_in_right_down[15]
  PIN data_out_left[0] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 6.307 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.3815 LAYER Metal3 ;
  END data_out_left[0]
  PIN data_out_left[1] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.774 LAYER Metal3 ;
  END data_out_left[1]
  PIN data_out_left[2] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 7.457 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.5565 LAYER Metal3 ;
  END data_out_left[2]
  PIN data_out_left[3] 
    ANTENNADIFFAREA 0.6159 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.597 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.1865 LAYER Metal3 ;
  END data_out_left[3]
  PIN data_out_left[4] 
    ANTENNADIFFAREA 0.6159 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.943 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2435 LAYER Metal3 ;
  END data_out_left[4]
  PIN data_out_left[5] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.695 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.6275 LAYER Metal3 ;
  END data_out_left[5]
  PIN data_out_left[6] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.439 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.4755 LAYER Metal3 ;
  END data_out_left[6]
  PIN data_out_left[7] 
    ANTENNADIFFAREA 0.6159 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.441 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.4845 LAYER Metal3 ;
  END data_out_left[7]
  PIN data_out_left[8] 
    ANTENNADIFFAREA 0.6159 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.807 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1315 LAYER Metal3 ;
  END data_out_left[8]
  PIN data_out_left[9] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.607 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.2315 LAYER Metal3 ;
  END data_out_left[9]
  PIN data_out_left[10] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.079 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3555 LAYER Metal3 ;
  END data_out_left[10]
  PIN data_out_left[11] 
    ANTENNADIFFAREA 0.6159 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 6.715 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.2175 LAYER Metal3 ;
  END data_out_left[11]
  PIN data_out_left[12] 
    ANTENNADIFFAREA 0.6159 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.9 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.55 LAYER Metal3 ;
  END data_out_left[12]
  PIN data_out_left[13] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 6.988 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.446 LAYER Metal3 ;
  END data_out_left[13]
  PIN data_out_left[14] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.86 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.87 LAYER Metal3 ;
  END data_out_left[14]
  PIN data_out_left[15] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.46 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal3 ;
  END data_out_left[15]
  PIN sel[2] 
    ANTENNAPARTIALMETALAREA 2.916 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.302 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6643 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.9799 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 54.9041 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.741332 LAYER Via3 ;
  END sel[2]
  PIN sel[1] 
    ANTENNAPARTIALMETALAREA 3.879 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.6355 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9178 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 25.1077 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 114.083 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via3 ;
  END sel[1]
  PIN sel[0] 
    ANTENNAPARTIALMETALAREA 2.631 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.0195 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7254 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 7.25393 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 32.7957 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.398125 LAYER Via3 ;
  END sel[0]
  PIN flag[0] 
    ANTENNADIFFAREA 0.662 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 16.3816 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 73.7145 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9672 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 25.1206 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 113.882 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.97043 LAYER Via3 ;
    ANTENNADIFFAREA 0.662 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.868 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.586 LAYER Metal4 ;
    ANTENNAGATEAREA 1.2462 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 26.6195 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 120.772 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.97043 LAYER Via4 ;
  END flag[0]
  PIN flag[1] 
    ANTENNADIFFAREA 0.662 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 4.838 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.7485 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.662 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.325 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.62 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNADIFFAREA 0.662 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.15 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 23.355 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.2462 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 22.2261 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 101.277 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.15278 LAYER TopVia1 ;
  END flag[1]
  PIN flag[2] 
    ANTENNADIFFAREA 0.7068 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 12.545 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.6325 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4836 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 29.5178 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 133.996 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.597188 LAYER Via3 ;
  END flag[2]
  PIN chip_sel_out[1] 
    ANTENNADIFFAREA 0.7586 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.188 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.846 LAYER Metal3 ;
  END chip_sel_out[1]
  PIN chip_sel_out[0] 
    ANTENNADIFFAREA 1.058 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.287 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.2915 LAYER Metal3 ;
  END chip_sel_out[0]
  PIN chip_sel 
    ANTENNAPARTIALMETALAREA 3.3 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.03 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8666 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 16.6247 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 75.143 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.713675 LAYER Via3 ;
  END chip_sel
END ecc_tbec_only

END LIBRARY
