

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO ecc_mux_reference 
  PIN data_in_left[0] 
    ANTENNAPARTIALMETALAREA 11.2668 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 50.868 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0816 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 22.5707 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 105.208 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.628448 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 12.223 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 55.1835 LAYER Metal4 ;
    ANTENNAGATEAREA 1.7173 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 29.6882 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 137.341 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.12578 LAYER Via4 ;
  END data_in_left[0]
  PIN data_in_left[1] 
    ANTENNAPARTIALMETALAREA 13.008 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 59.076 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0371 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 23.747 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 106.618 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via3 ;
  END data_in_left[1]
  PIN data_in_left[2] 
    ANTENNAPARTIALMETALAREA 9.213 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 41.436 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 19.6945 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 89.1246 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.703992 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.994 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.153 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0371 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 23.6187 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 106.872 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.703992 LAYER Via4 ;
  END data_in_left[2]
  PIN data_in_left[3] 
    ANTENNAPARTIALMETALAREA 13.389 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 60.5655 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 15.661 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 70.1546 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.726197 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 16.931 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 76.5495 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0371 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 23.9723 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 107.732 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.726197 LAYER Via4 ;
  END data_in_left[3]
  PIN data_in_left[4] 
    ANTENNAPARTIALMETALAREA 11.6428 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 52.4025 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0371 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.7208 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 64.3138 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.447891 LAYER Via3 ;
  END data_in_left[4]
  PIN data_in_left[5] 
    ANTENNAPARTIALMETALAREA 8.257 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.314 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8684 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.8487 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 62.9549 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.498848 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 10.894 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 49.383 LAYER Metal4 ;
    ANTENNAGATEAREA 1.7459 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 29.7988 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 135.167 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.12578 LAYER Via4 ;
  END data_in_left[5]
  PIN data_in_left[6] 
    ANTENNAPARTIALMETALAREA 14.4968 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 65.223 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5535 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.5016 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 61.0085 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.79296 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 12.638 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 57.051 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0371 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.7055 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 89.0145 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.79296 LAYER Via4 ;
  END data_in_left[6]
  PIN data_in_left[7] 
    ANTENNAPARTIALMETALAREA 14.311 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 64.737 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5535 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.4865 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 65.7643 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.535084 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.891 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.1895 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0371 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.851 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 85.4931 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.535084 LAYER Via4 ;
  END data_in_left[7]
  PIN data_in_left[8] 
    ANTENNAPARTIALMETALAREA 9.851 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 44.6895 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.3999 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 53.8081 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.597188 LAYER Via3 ;
  END data_in_left[8]
  PIN data_in_left[9] 
    ANTENNAPARTIALMETALAREA 4.376 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.6695 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4342 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.6333 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 52.8409 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.415707 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 11.128 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 50.4135 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.7548 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 85.1034 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.941987 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.008 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 27.216 LAYER Metal5 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 21.691 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 98.4042 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.941987 LAYER TopVia1 ;
  END data_in_left[9]
  PIN data_in_left[10] 
    ANTENNAPARTIALMETALAREA 15.001 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 67.4595 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8866 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 19.4796 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 87.0567 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.488608 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 12.127 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 54.9315 LAYER Metal4 ;
    ANTENNAGATEAREA 1.755 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 26.3896 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 118.357 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.12578 LAYER Via4 ;
  END data_in_left[10]
  PIN data_in_left[11] 
    ANTENNAPARTIALMETALAREA 11.777 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 53.334 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 10.7683 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 48.9796 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.643393 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.135 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.7875 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 27.1324 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 120.059 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.04508 LAYER Via4 ;
  END data_in_left[11]
  PIN data_in_left[12] 
    ANTENNAPARTIALMETALAREA 2.296 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.3095 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4342 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 6.87978 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 31.4498 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.415707 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 16.234 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 73.413 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 21.3936 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 97.6238 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.725157 LAYER Via4 ;
  END data_in_left[12]
  PIN data_in_left[13] 
    ANTENNAPARTIALMETALAREA 11.4848 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 51.669 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 20.3763 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 92.059 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.941987 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.807 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.289 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 25.3724 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 114.643 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.988192 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.556 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.682 LAYER Metal5 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 27.599 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 124.75 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.988192 LAYER TopVia1 ;
  END data_in_left[13]
  PIN data_in_left[14] 
    ANTENNAPARTIALMETALAREA 11.817 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 53.514 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.1182 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 55.1058 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.643393 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.978 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.581 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.8297 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 86.9436 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.643393 LAYER Via4 ;
  END data_in_left[14]
  PIN data_in_left[15] 
    ANTENNAPARTIALMETALAREA 2.842 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7665 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 9.38854 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 42.6473 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.512203 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.487 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.349 LAYER Metal4 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.109 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 46.1221 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.619008 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 14.348 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 64.746 LAYER Metal5 ;
    ANTENNAGATEAREA 1.755 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 37.5401 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 170.718 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.50104 LAYER TopVia1 ;
  END data_in_left[15]
  PIN data_out_right_up[0] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.651 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.4295 LAYER Metal4 ;
  END data_out_right_up[0]
  PIN data_out_right_up[1] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[1]
  PIN data_out_right_up[2] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.231 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5395 LAYER Metal4 ;
  END data_out_right_up[2]
  PIN data_out_right_up[3] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[3]
  PIN data_out_right_up[4] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[4]
  PIN data_out_right_up[5] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.432 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.944 LAYER Metal4 ;
  END data_out_right_up[5]
  PIN data_out_right_up[6] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.231 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5395 LAYER Metal4 ;
  END data_out_right_up[6]
  PIN data_out_right_up[7] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[7]
  PIN data_out_right_up[8] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.231 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5395 LAYER Metal4 ;
  END data_out_right_up[8]
  PIN data_out_right_up[9] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[9]
  PIN data_out_right_up[10] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.339 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.5255 LAYER Metal4 ;
  END data_out_right_up[10]
  PIN data_out_right_up[11] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.909 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0905 LAYER Metal4 ;
  END data_out_right_up[11]
  PIN data_out_right_up[12] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[12]
  PIN data_out_right_up[13] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.223 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0035 LAYER Metal4 ;
  END data_out_right_up[13]
  PIN data_out_right_up[14] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.583 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6235 LAYER Metal4 ;
  END data_out_right_up[14]
  PIN data_out_right_up[15] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.956 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.802 LAYER Metal4 ;
  END data_out_right_up[15]
  PIN data_out_right_down[0] 
    ANTENNADIFFAREA 0.6159 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.299 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.8455 LAYER Metal4 ;
  END data_out_right_down[0]
  PIN data_out_right_down[1] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.987 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9415 LAYER Metal4 ;
  END data_out_right_down[1]
  PIN data_out_right_down[2] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.669 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.0105 LAYER Metal4 ;
  END data_out_right_down[2]
  PIN data_out_right_down[3] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.957 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3065 LAYER Metal4 ;
  END data_out_right_down[3]
  PIN data_out_right_down[4] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.652 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.934 LAYER Metal4 ;
  END data_out_right_down[4]
  PIN data_out_right_down[5] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.975 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.3875 LAYER Metal4 ;
  END data_out_right_down[5]
  PIN data_out_right_down[6] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.652 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.934 LAYER Metal4 ;
  END data_out_right_down[6]
  PIN data_out_right_down[7] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.76 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.92 LAYER Metal4 ;
  END data_out_right_down[7]
  PIN data_out_right_down[8] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.68 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.06 LAYER Metal4 ;
  END data_out_right_down[8]
  PIN data_out_right_down[9] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.819 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1855 LAYER Metal4 ;
  END data_out_right_down[9]
  PIN data_out_right_down[10] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.155 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.6975 LAYER Metal4 ;
  END data_out_right_down[10]
  PIN data_out_right_down[11] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.011 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.5495 LAYER Metal4 ;
  END data_out_right_down[11]
  PIN data_out_right_down[12] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.827 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7215 LAYER Metal4 ;
  END data_out_right_down[12]
  PIN data_out_right_down[13] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.82 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.69 LAYER Metal4 ;
  END data_out_right_down[13]
  PIN data_out_right_down[14] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.055 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
  END data_out_right_down[14]
  PIN data_out_right_down[15] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.391 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7595 LAYER Metal4 ;
  END data_out_right_down[15]
  PIN data_in_right_up[0] 
    ANTENNAPARTIALMETALAREA 7.876 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.442 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5535 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.0532 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.6939 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.555842 LAYER Via4 ;
  END data_in_right_up[0]
  PIN data_in_right_up[1] 
    ANTENNAPARTIALMETALAREA 0.06 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 3.405 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 15.5025 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7433 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 25.7159 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 114.335 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.978613 LAYER TopVia1 ;
  END data_in_right_up[1]
  PIN data_in_right_up[2] 
    ANTENNAPARTIALMETALAREA 9.053 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.9185 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.1593 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.8236 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.0981 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.793662 LAYER Via4 ;
  END data_in_right_up[2]
  PIN data_in_right_up[3] 
    ANTENNAPARTIALMETALAREA 6.103 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.4635 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.1775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.8716 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 61.9794 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.66755 LAYER Via4 ;
  END data_in_right_up[3]
  PIN data_in_right_up[4] 
    ANTENNAPARTIALMETALAREA 9.847 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 44.3115 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.4219 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.6811 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 48.3835 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.484214 LAYER Via4 ;
  END data_in_right_up[4]
  PIN data_in_right_up[5] 
    ANTENNAPARTIALMETALAREA 10.941 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 49.4145 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.431 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.8306 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.0083 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via4 ;
  END data_in_right_up[5]
  PIN data_in_right_up[6] 
    ANTENNAPARTIALMETALAREA 8.606 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 38.907 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.9877 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.2988 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 87.656 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_right_up[6]
  PIN data_in_right_up[7] 
    ANTENNAPARTIALMETALAREA 6.543 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.6235 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.6728 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.352 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 56.5809 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.79296 LAYER Via4 ;
  END data_in_right_up[7]
  PIN data_in_right_up[8] 
    ANTENNAPARTIALMETALAREA 8.772 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 39.474 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.1892 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.7704 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 66.9691 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.916803 LAYER Via4 ;
  END data_in_right_up[8]
  PIN data_in_right_up[9] 
    ANTENNAPARTIALMETALAREA 6.7 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.15 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.1801 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.31587 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 40.3114 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.783637 LAYER Via4 ;
  END data_in_right_up[9]
  PIN data_in_right_up[10] 
    ANTENNAPARTIALMETALAREA 3.999 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.1755 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.4219 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.1747 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 55.2517 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.720138 LAYER Via4 ;
  END data_in_right_up[10]
  PIN data_in_right_up[11] 
    ANTENNAPARTIALMETALAREA 5.808 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.316 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.1801 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.3731 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.3433 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.876551 LAYER Via4 ;
  END data_in_right_up[11]
  PIN data_in_right_up[12] 
    ANTENNAPARTIALMETALAREA 7.976 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.072 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7849 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.9559 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 66.673 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.01595 LAYER Via4 ;
  END data_in_right_up[12]
  PIN data_in_right_up[13] 
    ANTENNAPARTIALMETALAREA 3.928 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.676 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7758 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.2734 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 43.605 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.936439 LAYER Via4 ;
  END data_in_right_up[13]
  PIN data_in_right_up[14] 
    ANTENNAPARTIALMETALAREA 3.247 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6115 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.21 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 7.24357 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 33.0479 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.540643 LAYER Via4 ;
  END data_in_right_up[14]
  PIN data_in_right_up[15] 
    ANTENNAPARTIALMETALAREA 4.423 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.9035 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5041 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.9725 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 66.5197 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.865745 LAYER Via4 ;
  END data_in_right_up[15]
  PIN data_in_right_down[0] 
    ANTENNAPARTIALMETALAREA 7.598 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.3485 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4433 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.3386 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 87.1836 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.651478 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.872 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 31.104 LAYER Metal5 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 25.4781 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 114.972 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.6615 LAYER TopVia1 ;
  END data_in_right_down[0]
  PIN data_in_right_down[1] 
    ANTENNAPARTIALMETALAREA 13.0118 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 58.383 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 11.3318 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 51.003 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 36.2313 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 164.711 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.04508 LAYER TopVia1 ;
  END data_in_right_down[1]
  PIN data_in_right_down[2] 
    ANTENNAPARTIALMETALAREA 9.093 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 41.2785 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1284 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.2362 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.6686 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.651478 LAYER Via4 ;
  END data_in_right_down[2]
  PIN data_in_right_down[3] 
    ANTENNAPARTIALMETALAREA 15.093 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 68.0985 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 48.6077 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 219.722 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_right_down[3]
  PIN data_in_right_down[4] 
    ANTENNAPARTIALMETALAREA 9.207 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 41.6115 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 32.4155 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 146.462 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.651478 LAYER Via4 ;
  END data_in_right_down[4]
  PIN data_in_right_down[5] 
    ANTENNAPARTIALMETALAREA 14.251 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 64.1295 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 40.5862 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 182.837 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.553277 LAYER Via4 ;
  END data_in_right_down[5]
  PIN data_in_right_down[6] 
    ANTENNAPARTIALMETALAREA 5.429 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.4305 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.1573 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 81.7764 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.290509 LAYER Via4 ;
  END data_in_right_down[6]
  PIN data_in_right_down[7] 
    ANTENNAPARTIALMETALAREA 13.336 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 60.012 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 32.0845 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 144.575 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.309504 LAYER Via4 ;
  END data_in_right_down[7]
  PIN data_in_right_down[8] 
    ANTENNAPARTIALMETALAREA 10.972 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 49.554 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.798 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 84.9668 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.373642 LAYER Via4 ;
  END data_in_right_down[8]
  PIN data_in_right_down[9] 
    ANTENNAPARTIALMETALAREA 12.688 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 57.276 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.5787 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 102.038 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.362906 LAYER Via4 ;
  END data_in_right_down[9]
  PIN data_in_right_down[10] 
    ANTENNAPARTIALMETALAREA 16.005 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 72.2025 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 29.2107 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 132.718 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_right_down[10]
  PIN data_in_right_down[11] 
    ANTENNAPARTIALMETALAREA 3.588 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1235 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 3.5 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 15.93 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 26.1852 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 118.5 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.469711 LAYER TopVia1 ;
  END data_in_right_down[11]
  PIN data_in_right_down[12] 
    ANTENNAPARTIALMETALAREA 13.374 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 60.363 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 25.5612 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 115.659 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.554696 LAYER Via4 ;
  END data_in_right_down[12]
  PIN data_in_right_down[13] 
    ANTENNAPARTIALMETALAREA 16.276 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 73.242 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 33.6231 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 151.471 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.362906 LAYER Via4 ;
  END data_in_right_down[13]
  PIN data_in_right_down[14] 
    ANTENNAPARTIALMETALAREA 14.0628 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 63.2925 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 26.9415 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 121.373 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.554696 LAYER Via4 ;
  END data_in_right_down[14]
  PIN data_in_right_down[15] 
    ANTENNAPARTIALMETALAREA 16.972 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 76.374 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 30.0965 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 136.077 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.554696 LAYER Via4 ;
  END data_in_right_down[15]
  PIN data_out_left[0] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.774 LAYER Metal3 ;
  END data_out_left[0]
  PIN data_out_left[1] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.996 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.982 LAYER Metal3 ;
  END data_out_left[1]
  PIN data_out_left[2] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.32 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.94 LAYER Metal3 ;
  END data_out_left[2]
  PIN data_out_left[3] 
    ANTENNADIFFAREA 0.6159 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 8.4188 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.7145 LAYER Metal3 ;
  END data_out_left[3]
  PIN data_out_left[4] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.748 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.366 LAYER Metal3 ;
  END data_out_left[4]
  PIN data_out_left[5] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.774 LAYER Metal3 ;
  END data_out_left[5]
  PIN data_out_left[6] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.609 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.2405 LAYER Metal3 ;
  END data_out_left[6]
  PIN data_out_left[7] 
    ANTENNADIFFAREA 0.6159 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 8.299 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.3455 LAYER Metal3 ;
  END data_out_left[7]
  PIN data_out_left[8] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.996 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.982 LAYER Metal3 ;
  END data_out_left[8]
  PIN data_out_left[9] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.039 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6755 LAYER Metal3 ;
  END data_out_left[9]
  PIN data_out_left[10] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 4.079 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3555 LAYER Metal3 ;
  END data_out_left[10]
  PIN data_out_left[11] 
    ANTENNADIFFAREA 0.6159 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 8.119 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 36.5355 LAYER Metal3 ;
  END data_out_left[11]
  PIN data_out_left[12] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.932 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.194 LAYER Metal3 ;
  END data_out_left[12]
  PIN data_out_left[13] 
    ANTENNADIFFAREA 1.058 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.26 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.67 LAYER Metal3 ;
  END data_out_left[13]
  PIN data_out_left[14] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 6.1 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.45 LAYER Metal3 ;
  END data_out_left[14]
  PIN data_out_left[15] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 8.236 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.062 LAYER Metal3 ;
  END data_out_left[15]
  PIN sel[2] 
    ANTENNAPARTIALMETALAREA 3.541 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1145 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.2675 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.6359 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 53.2887 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.607255 LAYER Via3 ;
  END sel[2]
  PIN sel[1] 
    ANTENNAPARTIALMETALAREA 4.113 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.8685 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6032 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 30.2867 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 137.575 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.19867 LAYER Via3 ;
  END sel[1]
  PIN sel[0] 
    ANTENNAPARTIALMETALAREA 12.239 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 55.6155 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.6744 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 47.8205 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 216.11 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.04508 LAYER Via3 ;
  END sel[0]
  PIN flag[0] 
    ANTENNAPARTIALMETALAREA 6.126 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.5445 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.656 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.632 LAYER Metal4 ;
  END flag[0]
  PIN flag[1] 
    ANTENNADIFFAREA 0.6324 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 9.7978 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 44.1 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2418 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 46.8219 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 212.074 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.597188 LAYER Via3 ;
  END flag[1]
  PIN flag[2] 
    ANTENNADIFFAREA 0.9992 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 7.075 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.8375 LAYER Metal3 ;
  END flag[2]
  PIN chip_sel_out[1] 
    ANTENNADIFFAREA 0.6492 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.9 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.55 LAYER Metal3 ;
  END chip_sel_out[1]
  PIN chip_sel_out[0] 
    ANTENNADIFFAREA 0.6492 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.774 LAYER Metal3 ;
  END chip_sel_out[0]
  PIN chip_sel 
    ANTENNAPARTIALMETALAREA 4.047 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3915 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8138 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 18.1176 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 81.6804 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.532318 LAYER Via3 ;
  END chip_sel
END ecc_mux_reference

END LIBRARY
