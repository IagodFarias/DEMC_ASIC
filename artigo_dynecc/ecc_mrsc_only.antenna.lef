

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO ecc_mrsc_only 
  PIN data_in_left[0] 
    ANTENNAPARTIALMETALAREA 4.78 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.51 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3026 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 10.5845 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 47.3365 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.430687 LAYER Via3 ;
  END data_in_left[0]
  PIN data_in_left[1] 
    ANTENNAPARTIALMETALAREA 10.167 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 45.909 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 18.8819 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 85.6012 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.662221 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.852 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.014 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.6713 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 93.7666 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.662221 LAYER Via4 ;
  END data_in_left[1]
  PIN data_in_left[2] 
    ANTENNAPARTIALMETALAREA 11.51 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 52.155 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.9591 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 63.4214 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.512203 LAYER Via3 ;
  END data_in_left[2]
  PIN data_in_left[3] 
    ANTENNAPARTIALMETALAREA 11.716 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 53.0595 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 16.2477 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 73.8729 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.662221 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.022 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.779 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.1438 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 82.5183 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.662221 LAYER Via4 ;
  END data_in_left[3]
  PIN data_in_left[4] 
    ANTENNAPARTIALMETALAREA 2.87 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8925 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4342 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 8.1649 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 37.2328 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.415707 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.67 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.875 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 23.2502 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 106.419 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.19438 LAYER Via4 ;
  END data_in_left[4]
  PIN data_in_left[5] 
    ANTENNAPARTIALMETALAREA 2.762 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4065 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4342 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 7.91617 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 36.1135 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.415707 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.162 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.909 LAYER Metal4 ;
    ANTENNAGATEAREA 1.3026 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.4255 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.8257 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.624684 LAYER Via4 ;
  END data_in_left[5]
  PIN data_in_left[6] 
    ANTENNAPARTIALMETALAREA 12.781 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 57.852 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 17.3719 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 78.9681 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.512924 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.995 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6575 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.9961 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 81.8904 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_left[6]
  PIN data_in_left[7] 
    ANTENNAPARTIALMETALAREA 8.868 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 39.8835 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4342 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 23.2085 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 104.796 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.415707 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.947 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.4415 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 25.0575 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 113.23 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via4 ;
  END data_in_left[7]
  PIN data_in_left[8] 
    ANTENNAPARTIALMETALAREA 2.1 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.4275 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.179 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1655 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.3654 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 60.976 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via4 ;
  END data_in_left[8]
  PIN data_in_left[9] 
    ANTENNAPARTIALMETALAREA 11.574 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 52.0605 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.0098 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 63.4002 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.321135 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.163 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4135 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.7395 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 66.7968 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_left[9]
  PIN data_in_left[10] 
    ANTENNAPARTIALMETALAREA 13.741 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 61.992 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.0608 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 20.634 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 93.0491 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.818582 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.76 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1 LAYER Metal4 ;
    ANTENNAGATEAREA 1.3026 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 21.9852 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 99.2674 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via4 ;
  END data_in_left[10]
  PIN data_in_left[11] 
    ANTENNAPARTIALMETALAREA 13.991 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 63.3195 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 26.7242 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 124.418 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via3 ;
  END data_in_left[11]
  PIN data_in_left[12] 
    ANTENNAPARTIALMETALAREA 11.6058 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 52.416 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 15.1036 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 68.8428 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via3 ;
  END data_in_left[12]
  PIN data_in_left[13] 
    ANTENNAPARTIALMETALAREA 13.433 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 60.606 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 17.1948 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 78.0763 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.577237 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.396 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.962 LAYER Metal4 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.4433 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 79.3073 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_left[13]
  PIN data_in_left[14] 
    ANTENNAPARTIALMETALAREA 4.086 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3645 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.67 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.875 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5938 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.2853 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 62.8749 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.597188 LAYER Via4 ;
  END data_in_left[14]
  PIN data_in_left[15] 
    ANTENNAPARTIALMETALAREA 15.424 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 69.768 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3026 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 20.9457 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 94.5793 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.75052 LAYER Via3 ;
  END data_in_left[15]
  PIN data_out_right_up[0] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 11.236 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 50.562 LAYER Metal4 ;
  END data_out_right_up[0]
  PIN data_out_right_up[1] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.167 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.7515 LAYER Metal4 ;
  END data_out_right_up[1]
  PIN data_out_right_up[2] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[2]
  PIN data_out_right_up[3] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.315 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9175 LAYER Metal4 ;
  END data_out_right_up[3]
  PIN data_out_right_up[4] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[4]
  PIN data_out_right_up[5] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 9.304 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 41.868 LAYER Metal4 ;
  END data_out_right_up[5]
  PIN data_out_right_up[6] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[6]
  PIN data_out_right_up[7] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[7]
  PIN data_out_right_up[8] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.987 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9415 LAYER Metal4 ;
  END data_out_right_up[8]
  PIN data_out_right_up[9] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[9]
  PIN data_out_right_up[10] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 11.263 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 50.6835 LAYER Metal4 ;
  END data_out_right_up[10]
  PIN data_out_right_up[11] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.903 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5635 LAYER Metal4 ;
  END data_out_right_up[11]
  PIN data_out_right_up[12] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.223 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0035 LAYER Metal4 ;
  END data_out_right_up[12]
  PIN data_out_right_up[13] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.895 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0275 LAYER Metal4 ;
  END data_out_right_up[13]
  PIN data_out_right_up[14] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.221 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9945 LAYER Metal4 ;
  END data_out_right_up[14]
  PIN data_out_right_up[15] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 9.067 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.8015 LAYER Metal4 ;
  END data_out_right_up[15]
  PIN data_out_right_down[0] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.223 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0035 LAYER Metal4 ;
  END data_out_right_down[0]
  PIN data_out_right_down[1] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.484 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.178 LAYER Metal4 ;
  END data_out_right_down[1]
  PIN data_out_right_down[2] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.188 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.846 LAYER Metal4 ;
  END data_out_right_down[2]
  PIN data_out_right_down[3] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.164 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.738 LAYER Metal4 ;
  END data_out_right_down[3]
  PIN data_out_right_down[4] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.359 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6155 LAYER Metal4 ;
  END data_out_right_down[4]
  PIN data_out_right_down[5] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.676 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.542 LAYER Metal4 ;
  END data_out_right_down[5]
  PIN data_out_right_down[6] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_down[6]
  PIN data_out_right_down[7] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.616 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.272 LAYER Metal4 ;
  END data_out_right_down[7]
  PIN data_out_right_down[8] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.239 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.0755 LAYER Metal4 ;
  END data_out_right_down[8]
  PIN data_out_right_down[9] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.659 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9655 LAYER Metal4 ;
  END data_out_right_down[9]
  PIN data_out_right_down[10] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.587 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.6415 LAYER Metal4 ;
  END data_out_right_down[10]
  PIN data_out_right_down[11] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.659 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9655 LAYER Metal4 ;
  END data_out_right_down[11]
  PIN data_out_right_down[12] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.447 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.0115 LAYER Metal4 ;
  END data_out_right_down[12]
  PIN data_out_right_down[13] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.736 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.312 LAYER Metal4 ;
  END data_out_right_down[13]
  PIN data_out_right_down[14] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.139 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.6255 LAYER Metal4 ;
  END data_out_right_down[14]
  PIN data_out_right_down[15] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.223 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0035 LAYER Metal4 ;
  END data_out_right_down[15]
  PIN data_in_right_up[0] 
    ANTENNAPARTIALMETALAREA 10.887 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 49.1715 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7953 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.3726 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 67.7672 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.553981 LAYER Via4 ;
  END data_in_right_up[0]
  PIN data_in_right_up[1] 
    ANTENNAPARTIALMETALAREA 8.671 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 39.0195 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3611 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 21.6435 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 96.4385 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_right_up[1]
  PIN data_in_right_up[2] 
    ANTENNAPARTIALMETALAREA 8.886 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.167 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.8044 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.3033 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 55.8192 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.786498 LAYER Via4 ;
  END data_in_right_up[2]
  PIN data_in_right_up[3] 
    ANTENNAPARTIALMETALAREA 6.691 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.1095 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3611 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.2182 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 72.1008 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.810989 LAYER Via4 ;
  END data_in_right_up[3]
  PIN data_in_right_up[4] 
    ANTENNAPARTIALMETALAREA 6.832 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.744 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0059 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.7358 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 59.8313 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.409635 LAYER Via4 ;
  END data_in_right_up[4]
  PIN data_in_right_up[5] 
    ANTENNAPARTIALMETALAREA 4.684 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.078 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.9968 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.7584 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 47.8546 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.633346 LAYER Via4 ;
  END data_in_right_up[5]
  PIN data_in_right_up[6] 
    ANTENNAPARTIALMETALAREA 7.003 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.6935 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.9968 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.487 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 101.391 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.732912 LAYER Via4 ;
  END data_in_right_up[6]
  PIN data_in_right_up[7] 
    ANTENNAPARTIALMETALAREA 4.275 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.4175 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.9968 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.8072 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 59.8094 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.604613 LAYER Via4 ;
  END data_in_right_up[7]
  PIN data_in_right_up[8] 
    ANTENNAPARTIALMETALAREA 16.212 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 73.134 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.9968 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.5345 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 56.8521 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.511875 LAYER Via4 ;
  END data_in_right_up[8]
  PIN data_in_right_up[9] 
    ANTENNAPARTIALMETALAREA 6.195 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.0575 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.548 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 48.0345 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.6615 LAYER Via4 ;
  END data_in_right_up[9]
  PIN data_in_right_up[10] 
    ANTENNAPARTIALMETALAREA 10.264 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 46.188 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0059 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.8034 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 94.1177 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.57335 LAYER Via4 ;
  END data_in_right_up[10]
  PIN data_in_right_up[11] 
    ANTENNAPARTIALMETALAREA 6.624 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.988 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.2381 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 49.1985 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.5769 LAYER Via4 ;
  END data_in_right_up[11]
  PIN data_in_right_up[12] 
    ANTENNAPARTIALMETALAREA 4.507 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.2815 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3611 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 8.07621 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 33.8196 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.525785 LAYER Via4 ;
  END data_in_right_up[12]
  PIN data_in_right_up[13] 
    ANTENNAPARTIALMETALAREA 4.024 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.108 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7953 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 7.05239 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 29.7007 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.488107 LAYER Via4 ;
  END data_in_right_up[13]
  PIN data_in_right_up[14] 
    ANTENNAPARTIALMETALAREA 0.559 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5155 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.3611 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.54661 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 43.5657 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.500936 LAYER Via4 ;
  END data_in_right_up[14]
  PIN data_in_right_up[15] 
    ANTENNAPARTIALMETALAREA 3.34 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.03 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.8044 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 8.17491 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 34.9249 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.500936 LAYER Via4 ;
  END data_in_right_up[15]
  PIN data_in_right_down[0] 
    ANTENNAPARTIALMETALAREA 8.968 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.356 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.6711 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 101.61 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.512395 LAYER Via4 ;
  END data_in_right_down[0]
  PIN data_in_right_down[1] 
    ANTENNAPARTIALMETALAREA 12.407 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 55.989 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.283 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.9535 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 17.8852 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 81.7181 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.04508 LAYER TopVia1 ;
  END data_in_right_down[1]
  PIN data_in_right_down[2] 
    ANTENNAPARTIALMETALAREA 9.232 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 41.544 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1193 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.829 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 93.5913 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.480212 LAYER Via4 ;
  END data_in_right_down[2]
  PIN data_in_right_down[3] 
    ANTENNAPARTIALMETALAREA 12.887 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 57.9915 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 39.242 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 177.175 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.554696 LAYER Via4 ;
  END data_in_right_down[3]
  PIN data_in_right_down[4] 
    ANTENNAPARTIALMETALAREA 7.613 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.2585 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5717 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.0813 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 63.4328 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.290242 LAYER Via4 ;
  END data_in_right_down[4]
  PIN data_in_right_down[5] 
    ANTENNAPARTIALMETALAREA 12.425 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 55.9125 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 33.5677 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 151.376 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.593994 LAYER Via4 ;
  END data_in_right_down[5]
  PIN data_in_right_down[6] 
    ANTENNAPARTIALMETALAREA 10.072 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.324 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1284 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 21.7576 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 98.0801 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.511875 LAYER Via4 ;
  END data_in_right_down[6]
  PIN data_in_right_down[7] 
    ANTENNAPARTIALMETALAREA 12.784 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 57.528 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 27.7701 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 125.624 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.431125 LAYER Via4 ;
  END data_in_right_down[7]
  PIN data_in_right_down[8] 
    ANTENNAPARTIALMETALAREA 6.753 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.5685 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.9846 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 81.7761 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.553277 LAYER Via4 ;
  END data_in_right_down[8]
  PIN data_in_right_down[9] 
    ANTENNAPARTIALMETALAREA 13.0551 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 58.725 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 5.133 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 23.2785 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 27.1344 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 123.601 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.851871 LAYER TopVia1 ;
  END data_in_right_down[9]
  PIN data_in_right_down[10] 
    ANTENNAPARTIALMETALAREA 8.044 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.198 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 29.5752 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 133.671 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.553277 LAYER Via4 ;
  END data_in_right_down[10]
  PIN data_in_right_down[11] 
    ANTENNAPARTIALMETALAREA 12.016 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 54.072 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 30.4774 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 137.469 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.593994 LAYER Via4 ;
  END data_in_right_down[11]
  PIN data_in_right_down[12] 
    ANTENNAPARTIALMETALAREA 12.147 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 55.0215 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 27.1716 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 123.585 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.814347 LAYER Via4 ;
  END data_in_right_down[12]
  PIN data_in_right_down[13] 
    ANTENNAPARTIALMETALAREA 14.335 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 64.5075 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 29.4569 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 133.139 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.553277 LAYER Via4 ;
  END data_in_right_down[13]
  PIN data_in_right_down[14] 
    ANTENNAPARTIALMETALAREA 13.734 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 61.983 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 25.2996 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 114.648 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_right_down[14]
  PIN data_in_right_down[15] 
    ANTENNAPARTIALMETALAREA 14.423 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 64.9035 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 24.9277 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 112.757 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.553277 LAYER Via4 ;
  END data_in_right_down[15]
  PIN data_out_left[0] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.774 LAYER Metal3 ;
  END data_out_left[0]
  PIN data_out_left[1] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.774 LAYER Metal3 ;
  END data_out_left[1]
  PIN data_out_left[2] 
    ANTENNAPARTIALMETALAREA 4.308 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.3635 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.096 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.612 LAYER Metal4 ;
  END data_out_left[2]
  PIN data_out_left[3] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.132 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.094 LAYER Metal3 ;
  END data_out_left[3]
  PIN data_out_left[4] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.804 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.118 LAYER Metal3 ;
  END data_out_left[4]
  PIN data_out_left[5] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.774 LAYER Metal3 ;
  END data_out_left[5]
  PIN data_out_left[6] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.5588 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.8445 LAYER Metal3 ;
  END data_out_left[6]
  PIN data_out_left[7] 
    ANTENNAPARTIALMETALAREA 2.004 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9955 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.418 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0385 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNADIFFAREA 0.6772 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 6.494 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 29.403 LAYER Metal5 ;
  END data_out_left[7]
  PIN data_out_left[8] 
    ANTENNAPARTIALMETALAREA 3.138 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.0985 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.438 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.651 LAYER Metal4 ;
  END data_out_left[8]
  PIN data_out_left[9] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.548 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.466 LAYER Metal3 ;
  END data_out_left[9]
  PIN data_out_left[10] 
    ANTENNAPARTIALMETALAREA 0.27 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1925 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 7.286 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 32.967 LAYER Metal4 ;
  END data_out_left[10]
  PIN data_out_left[11] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.911 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.5995 LAYER Metal3 ;
  END data_out_left[11]
  PIN data_out_left[12] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.774 LAYER Metal3 ;
  END data_out_left[12]
  PIN data_out_left[13] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 5.644 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.398 LAYER Metal3 ;
  END data_out_left[13]
  PIN data_out_left[14] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.734 LAYER Metal3 ;
  END data_out_left[14]
  PIN data_out_left[15] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 7.66 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 34.47 LAYER Metal3 ;
  END data_out_left[15]
  PIN sel[2] 
    ANTENNAPARTIALMETALAREA 3.028 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.626 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6643 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 6.924 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 31.2484 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.308464 LAYER Via3 ;
  END sel[2]
  PIN sel[1] 
    ANTENNAPARTIALMETALAREA 4.1568 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.7155 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7254 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.3166 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 51.2283 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.597188 LAYER Via3 ;
  END sel[1]
  PIN sel[0] 
    ANTENNAPARTIALMETALAREA 4.068 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.486 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8567 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 22.5681 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 102.294 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via3 ;
  END sel[0]
  PIN flag[0] 
    ANTENNADIFFAREA 0.2992 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.22 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.17 LAYER Metal3 ;
  END flag[0]
  PIN flag[1] 
    ANTENNADIFFAREA 0.2992 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.22 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.17 LAYER Metal3 ;
  END flag[1]
  PIN flag[2] 
    ANTENNADIFFAREA 0.2992 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.22 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.17 LAYER Metal3 ;
  END flag[2]
  PIN chip_sel_out[1] 
    ANTENNADIFFAREA 0.7586 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.903 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5635 LAYER Metal3 ;
  END chip_sel_out[1]
  PIN chip_sel_out[0] 
    ANTENNADIFFAREA 1.058 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.734 LAYER Metal3 ;
  END chip_sel_out[0]
  PIN chip_sel 
    ANTENNAPARTIALMETALAREA 4.2898 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.314 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8666 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 10.4317 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 47.078 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.713675 LAYER Via3 ;
  END chip_sel
END ecc_mrsc_only

END LIBRARY
