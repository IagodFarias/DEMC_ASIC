

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO ecc_design 
  PIN data_in_left[0] 
    ANTENNAPARTIALMETALAREA 9.992 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 45.144 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.7433 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 17.6072 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 80.2252 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.570445 LAYER Via3 ;
  END data_in_left[0]
  PIN data_in_left[1] 
    ANTENNAPARTIALMETALAREA 10.835 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 48.915 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.7838 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 62.6187 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.643393 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.539 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1055 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.5133 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 70.4896 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_left[1]
  PIN data_in_left[2] 
    ANTENNAPARTIALMETALAREA 12.966 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 58.5045 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.4918 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 60.0616 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.643393 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.422 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.579 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.1641 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 67.6753 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.643393 LAYER Via4 ;
  END data_in_left[2]
  PIN data_in_left[3] 
    ANTENNAPARTIALMETALAREA 5.661 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.452 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.9909 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 59.2762 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.703992 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.347 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.2415 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.0949 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.8111 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.09777 LAYER Via4 ;
  END data_in_left[3]
  PIN data_in_left[4] 
    ANTENNAPARTIALMETALAREA 11.078 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 50.211 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.8044 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 17.3328 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 78.9271 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via3 ;
  END data_in_left[4]
  PIN data_in_left[5] 
    ANTENNAPARTIALMETALAREA 12.958 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 58.491 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.4621 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 52.1854 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.597188 LAYER Via3 ;
  END data_in_left[5]
  PIN data_in_left[6] 
    ANTENNAPARTIALMETALAREA 12.785 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 57.8925 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.8044 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.6219 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 61.6645 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via3 ;
  END data_in_left[6]
  PIN data_in_left[7] 
    ANTENNAPARTIALMETALAREA 13.6368 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 61.3755 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.8044 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.6156 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 57.112 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.675082 LAYER Via3 ;
  END data_in_left[7]
  PIN data_in_left[8] 
    ANTENNAPARTIALMETALAREA 10.375 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 46.845 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.0974 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 54.9789 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.941987 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.34 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.21 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.7523 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 58.0138 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.941987 LAYER Via4 ;
  END data_in_left[8]
  PIN data_in_left[9] 
    ANTENNAPARTIALMETALAREA 11.766 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 53.127 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.9288 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 58.6416 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.895782 LAYER Via3 ;
  END data_in_left[9]
  PIN data_in_left[10] 
    ANTENNAPARTIALMETALAREA 16.917 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 76.284 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.5626 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 18.9705 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 86.2256 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.941987 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 11.063 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 49.9635 LAYER Metal4 ;
    ANTENNAGATEAREA 1.7433 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 25.3165 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 114.886 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.998893 LAYER Via4 ;
  END data_in_left[10]
  PIN data_in_left[11] 
    ANTENNAPARTIALMETALAREA 17.6678 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 79.695 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.3123 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 61.7476 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.597188 LAYER Via3 ;
  END data_in_left[11]
  PIN data_in_left[12] 
    ANTENNAPARTIALMETALAREA 12.46 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 56.43 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.6075 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 57.4006 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.597188 LAYER Via3 ;
  END data_in_left[12]
  PIN data_in_left[13] 
    ANTENNAPARTIALMETALAREA 13.758 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 62.0685 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1596 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 25.3086 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 114.491 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.659451 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.676 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.722 LAYER Metal4 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 26.1277 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 118.265 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.659451 LAYER Via4 ;
  END data_in_left[13]
  PIN data_in_left[14] 
    ANTENNAPARTIALMETALAREA 13.628 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 61.686 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0462 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.7486 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 68.2969 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.651478 LAYER Via3 ;
  END data_in_left[14]
  PIN data_in_left[15] 
    ANTENNAPARTIALMETALAREA 2.274 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.2105 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.921 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.302 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.83219 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 45.0022 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAMAXCUTCAR 0.469711 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 11.864 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 53.568 LAYER Metal5 ;
    ANTENNAGATEAREA 1.7433 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 40.9698 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 186.145 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.31438 LAYER TopVia1 ;
  END data_in_left[15]
  PIN data_out_right_up[0] 
    ANTENNADIFFAREA 0.662 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 12.1 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 54.45 LAYER Metal4 ;
  END data_out_right_up[0]
  PIN data_out_right_up[1] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 10.758 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 48.591 LAYER Metal4 ;
  END data_out_right_up[1]
  PIN data_out_right_up[2] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[2]
  PIN data_out_right_up[3] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.231 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5395 LAYER Metal4 ;
  END data_out_right_up[3]
  PIN data_out_right_up[4] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.827 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7215 LAYER Metal4 ;
  END data_out_right_up[4]
  PIN data_out_right_up[5] 
    ANTENNADIFFAREA 0.662 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.676 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.542 LAYER Metal4 ;
  END data_out_right_up[5]
  PIN data_out_right_up[6] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[6]
  PIN data_out_right_up[7] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[7]
  PIN data_out_right_up[8] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.071 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3195 LAYER Metal4 ;
  END data_out_right_up[8]
  PIN data_out_right_up[9] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 11.311 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 50.8995 LAYER Metal4 ;
  END data_out_right_up[9]
  PIN data_out_right_up[10] 
    ANTENNADIFFAREA 0.662 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.827 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7215 LAYER Metal4 ;
  END data_out_right_up[10]
  PIN data_out_right_up[11] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.827 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7215 LAYER Metal4 ;
  END data_out_right_up[11]
  PIN data_out_right_up[12] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.055 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
  END data_out_right_up[12]
  PIN data_out_right_up[13] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 12.643 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 56.8935 LAYER Metal4 ;
  END data_out_right_up[13]
  PIN data_out_right_up[14] 
    ANTENNADIFFAREA 0.6324 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.223 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0035 LAYER Metal4 ;
  END data_out_right_up[14]
  PIN data_out_right_up[15] 
    ANTENNADIFFAREA 0.662 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.019 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.5855 LAYER Metal4 ;
  END data_out_right_up[15]
  PIN data_out_right_down[0] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.268 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.706 LAYER Metal4 ;
  END data_out_right_down[0]
  PIN data_out_right_down[1] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.985 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9325 LAYER Metal4 ;
  END data_out_right_down[1]
  PIN data_out_right_down[2] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.44 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.98 LAYER Metal4 ;
  END data_out_right_down[2]
  PIN data_out_right_down[3] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.055 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
  END data_out_right_down[3]
  PIN data_out_right_down[4] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.735 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.8075 LAYER Metal4 ;
  END data_out_right_down[4]
  PIN data_out_right_down[5] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.158 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.891 LAYER Metal4 ;
  END data_out_right_down[5]
  PIN data_out_right_down[6] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.225 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6925 LAYER Metal4 ;
  END data_out_right_down[6]
  PIN data_out_right_down[7] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.324 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.958 LAYER Metal4 ;
  END data_out_right_down[7]
  PIN data_out_right_down[8] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.332 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.494 LAYER Metal4 ;
  END data_out_right_down[8]
  PIN data_out_right_down[9] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.659 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9655 LAYER Metal4 ;
  END data_out_right_down[9]
  PIN data_out_right_down[10] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.408 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.336 LAYER Metal4 ;
  END data_out_right_down[10]
  PIN data_out_right_down[11] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.659 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9655 LAYER Metal4 ;
  END data_out_right_down[11]
  PIN data_out_right_down[12] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.499 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.7455 LAYER Metal4 ;
  END data_out_right_down[12]
  PIN data_out_right_down[13] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.307 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3815 LAYER Metal4 ;
  END data_out_right_down[13]
  PIN data_out_right_down[14] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.707 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.6815 LAYER Metal4 ;
  END data_out_right_down[14]
  PIN data_out_right_down[15] 
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.287 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.7915 LAYER Metal4 ;
  END data_out_right_down[15]
  PIN data_in_right_up[0] 
    ANTENNAPARTIALMETALAREA 12.567 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 56.7315 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.431 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.1944 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 49.9864 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.518308 LAYER Via4 ;
  END data_in_right_up[0]
  PIN data_in_right_up[1] 
    ANTENNAPARTIALMETALAREA 11.762 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 53.109 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.352 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.1843 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 91.4905 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_right_up[1]
  PIN data_in_right_up[2] 
    ANTENNAPARTIALMETALAREA 10.491 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 47.3895 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.2386 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.5836 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 92.3097 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.650233 LAYER Via4 ;
  END data_in_right_up[2]
  PIN data_in_right_up[3] 
    ANTENNAPARTIALMETALAREA 9.978 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.081 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.352 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 21.259 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 96.6183 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.810797 LAYER Via4 ;
  END data_in_right_up[3]
  PIN data_in_right_up[4] 
    ANTENNAPARTIALMETALAREA 10.912 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 49.104 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.2295 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.0745 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 66.4335 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.942531 LAYER Via4 ;
  END data_in_right_up[4]
  PIN data_in_right_up[5] 
    ANTENNAPARTIALMETALAREA 12.731 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 57.4695 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.4219 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 12.2875 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 55.6773 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.498848 LAYER Via4 ;
  END data_in_right_up[5]
  PIN data_in_right_up[6] 
    ANTENNAPARTIALMETALAREA 5.352 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.264 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.2477 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.6597 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 84.5549 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.818472 LAYER Via4 ;
  END data_in_right_up[6]
  PIN data_in_right_up[7] 
    ANTENNAPARTIALMETALAREA 6.851 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.1895 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.2386 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.83159 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 45.3139 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.04508 LAYER Via4 ;
  END data_in_right_up[7]
  PIN data_in_right_up[8] 
    ANTENNAPARTIALMETALAREA 12.176 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 54.792 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.691 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.8248 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 52.9148 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_right_up[8]
  PIN data_in_right_up[9] 
    ANTENNAPARTIALMETALAREA 0.055 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.2295 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.8039 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 103.126 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.629572 LAYER Via4 ;
  END data_in_right_up[9]
  PIN data_in_right_up[10] 
    ANTENNAPARTIALMETALAREA 10.548 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 47.466 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.4492 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 10.3972 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 47.3166 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.511875 LAYER Via4 ;
  END data_in_right_up[10]
  PIN data_in_right_up[11] 
    ANTENNAPARTIALMETALAREA 4.971 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.5495 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.2386 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 11.1019 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 50.5175 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.502651 LAYER Via4 ;
  END data_in_right_up[11]
  PIN data_in_right_up[12] 
    ANTENNAPARTIALMETALAREA 8.042 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.369 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.2386 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.2416 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 73.596 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.903817 LAYER Via4 ;
  END data_in_right_up[12]
  PIN data_in_right_up[13] 
    ANTENNAPARTIALMETALAREA 5.452 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.534 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.6728 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 9.67022 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 44.2885 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.68373 LAYER Via4 ;
  END data_in_right_up[13]
  PIN data_in_right_up[14] 
    ANTENNAPARTIALMETALAREA 2.164 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.738 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.2477 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 7.79069 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 33.1502 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.480013 LAYER Via4 ;
  END data_in_right_up[14]
  PIN data_in_right_up[15] 
    ANTENNAPARTIALMETALAREA 2.935 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2075 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.0059 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 8.33161 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 38.4895 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.534813 LAYER Via4 ;
  END data_in_right_up[15]
  PIN data_in_right_down[0] 
    ANTENNAPARTIALMETALAREA 5.95113 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.757 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 9.168 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.436 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 24.4547 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 111.131 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.6615 LAYER TopVia1 ;
  END data_in_right_down[0]
  PIN data_in_right_down[1] 
    ANTENNAPARTIALMETALAREA 0.06 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2475 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.891 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 40.1895 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 55.2541 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 250.31 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.15046 LAYER TopVia1 ;
  END data_in_right_down[1]
  PIN data_in_right_down[2] 
    ANTENNAPARTIALMETALAREA 7.975 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.8875 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 28.8001 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 130.183 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.553277 LAYER Via4 ;
  END data_in_right_down[2]
  PIN data_in_right_down[3] 
    ANTENNAPARTIALMETALAREA 3.78 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.9875 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.263 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 28.3635 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 29.8825 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 135.613 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.6615 LAYER TopVia1 ;
  END data_in_right_down[3]
  PIN data_in_right_down[4] 
    ANTENNAPARTIALMETALAREA 7.555 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.9975 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.3108 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 100.865 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.512924 LAYER Via4 ;
  END data_in_right_down[4]
  PIN data_in_right_down[5] 
    ANTENNAPARTIALMETALAREA 16.11 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 72.675 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 54.7157 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 246.915 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.746485 LAYER Via4 ;
  END data_in_right_down[5]
  PIN data_in_right_down[6] 
    ANTENNAPARTIALMETALAREA 11.356 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 51.102 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 31.6583 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 143.453 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.522512 LAYER Via4 ;
  END data_in_right_down[6]
  PIN data_in_right_down[7] 
    ANTENNAPARTIALMETALAREA 13.579 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 61.1055 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1102 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.804 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 102.694 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.321135 LAYER Via4 ;
  END data_in_right_down[7]
  PIN data_in_right_down[8] 
    ANTENNAPARTIALMETALAREA 6.112 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.504 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 24.6628 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 111.588 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.554696 LAYER Via4 ;
  END data_in_right_down[8]
  PIN data_in_right_down[9] 
    ANTENNAPARTIALMETALAREA 16.203 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 73.0935 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 70.5612 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 316.741 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 1.04508 LAYER Via4 ;
  END data_in_right_down[9]
  PIN data_in_right_down[10] 
    ANTENNAPARTIALMETALAREA 8.574 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 38.763 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.1885 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 100.7 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.554696 LAYER Via4 ;
  END data_in_right_down[10]
  PIN data_in_right_down[11] 
    ANTENNAPARTIALMETALAREA 3.93 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.6625 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.259 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 19.3455 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 22.9957 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 103.902 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.469711 LAYER TopVia1 ;
  END data_in_right_down[11]
  PIN data_in_right_down[12] 
    ANTENNAPARTIALMETALAREA 8.803 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 39.6135 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.6825 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 102.232 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.360069 LAYER Via4 ;
  END data_in_right_down[12]
  PIN data_in_right_down[13] 
    ANTENNAPARTIALMETALAREA 14.611 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 65.7495 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.6851 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 32.5563 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 144.377 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.509366 LAYER Via4 ;
  END data_in_right_down[13]
  PIN data_in_right_down[14] 
    ANTENNAPARTIALMETALAREA 12.592 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 56.664 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 31.7468 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 141.485 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.554696 LAYER Via4 ;
  END data_in_right_down[14]
  PIN data_in_right_down[15] 
    ANTENNAPARTIALMETALAREA 15.463 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 69.5835 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.676 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 34.8808 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 157.549 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.554696 LAYER Via4 ;
  END data_in_right_down[15]
  PIN data_out_left[0] 
    ANTENNAPARTIALMETALAREA 3.432 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.4215 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.348 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.746 LAYER Metal4 ;
  END data_out_left[0]
  PIN data_out_left[1] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.177 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.7965 LAYER Metal3 ;
  END data_out_left[1]
  PIN data_out_left[2] 
    ANTENNAPARTIALMETALAREA 3.156 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.1795 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.792 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.744 LAYER Metal4 ;
  END data_out_left[2]
  PIN data_out_left[3] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.191 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8595 LAYER Metal3 ;
  END data_out_left[3]
  PIN data_out_left[4] 
    ANTENNADIFFAREA 0.6324 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.172 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.774 LAYER Metal3 ;
  END data_out_left[4]
  PIN data_out_left[5] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.996 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.982 LAYER Metal3 ;
  END data_out_left[5]
  PIN data_out_left[6] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.1748 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.1165 LAYER Metal3 ;
  END data_out_left[6]
  PIN data_out_left[7] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 6.5228 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.1825 LAYER Metal3 ;
  END data_out_left[7]
  PIN data_out_left[8] 
    ANTENNADIFFAREA 0.6324 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.94 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.23 LAYER Metal3 ;
  END data_out_left[8]
  PIN data_out_left[9] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.371 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.6695 LAYER Metal3 ;
  END data_out_left[9]
  PIN data_out_left[10] 
    ANTENNAPARTIALMETALAREA 2.19 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8325 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.477 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.3265 LAYER Metal4 ;
  END data_out_left[10]
  PIN data_out_left[11] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 7.432 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.444 LAYER Metal3 ;
  END data_out_left[11]
  PIN data_out_left[12] 
    ANTENNAPARTIALMETALAREA 4.764 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.4155 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.008 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.216 LAYER Metal4 ;
  END data_out_left[12]
  PIN data_out_left[13] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.561 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5245 LAYER Metal3 ;
  END data_out_left[13]
  PIN data_out_left[14] 
    ANTENNAPARTIALMETALAREA 6.798 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.5685 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNADIFFAREA 0.6772 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.116 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.702 LAYER Metal4 ;
  END data_out_left[14]
  PIN data_out_left[15] 
    ANTENNADIFFAREA 0.6772 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.9 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.55 LAYER Metal3 ;
  END data_out_left[15]
  PIN sel[2] 
    ANTENNAPARTIALMETALAREA 2.668 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9835 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2457 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.254 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 55.9768 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.734636 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.246 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.287 LAYER Metal4 ;
    ANTENNAGATEAREA 0.8489 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.8451 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 80.8267 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.734636 LAYER Via4 ;
  END sel[2]
  PIN sel[1] 
    ANTENNAPARTIALMETALAREA 2.188 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.846 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7665 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 10.88 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 49.2761 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.392788 LAYER Via3 ;
  END sel[1]
  PIN sel[0] 
    ANTENNAPARTIALMETALAREA 5.109 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.148 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7626 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 21.991 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 98.9812 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER Via3 ;
    ANTENNAMAXCUTCAR 0.691864 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.498 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.421 LAYER Metal4 ;
    ANTENNAGATEAREA 1.9339 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 23.2827 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 104.887 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 0.691864 LAYER Via4 ;
  END sel[0]
  PIN flag[0] 
    ANTENNADIFFAREA 0.6884 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.9 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.55 LAYER Metal3 ;
  END flag[0]
  PIN flag[1] 
    ANTENNADIFFAREA 0.6884 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.804 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.118 LAYER Metal3 ;
  END flag[1]
  PIN flag[2] 
    ANTENNADIFFAREA 0.8449 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.476 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.142 LAYER Metal3 ;
  END flag[2]
  PIN chip_sel_out[1] 
    ANTENNADIFFAREA 0.7586 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.04 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.68 LAYER Metal3 ;
  END chip_sel_out[1]
  PIN chip_sel_out[0] 
    ANTENNADIFFAREA 0.7586 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.996 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.982 LAYER Metal3 ;
  END chip_sel_out[0]
  PIN chip_sel 
    ANTENNAPARTIALMETALAREA 2.941 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2345 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8684 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 5.54957 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 25.3829 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.249424 LAYER Via3 ;
  END chip_sel
END ecc_design

END LIBRARY
